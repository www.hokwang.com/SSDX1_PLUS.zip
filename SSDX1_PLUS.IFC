Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: SSDX1_PLUS.IFC
Time: 2026-07-29T06:23:38
Written by: SwIFC
Made in: SolidWorks 2023

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: A0127-0072_HK-MSD_消毒機500cc外殼導光柱
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: HK-SSD_PLUS-20220411
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: HK-SSD_消毒機背板_加大1.2倍
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 多功能皂閥-泡沫出口件
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 大容量給皂機_透視窗_220411
In: Default Storey
PredefinedType: ELEMENT; Material: 0
